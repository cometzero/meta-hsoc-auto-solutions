# SPDX-License-Identifier: MIT

inherit features_check

REQUIRED_DISTRO_FEATURES += "systemd overlayfs"
