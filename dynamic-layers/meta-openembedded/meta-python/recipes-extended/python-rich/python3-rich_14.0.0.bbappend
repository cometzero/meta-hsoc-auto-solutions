# SPDX-License-Identifier: MIT

BBCLASSEXTEND += "native nativesdk"
