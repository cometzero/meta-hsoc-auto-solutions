FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-lat-mem-rd-add-sample-duration-option.patch"
