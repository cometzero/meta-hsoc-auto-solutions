# SPDX-License-Identifier: MIT
require zephyr-si-cl1-bench.bb

SUMMARY = "Standalone Apollo SI CL1 Zephyr SMP boot smoke for QBox"
ZEPHYR_SRC_DIR = "${HSOC_APOLLO_ZEPHYR_HSOC_SRC}/apps/si_cl1_boot"
